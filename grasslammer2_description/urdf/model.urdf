Commit message: added oakd-pro-w camera

File: grasslammer2_description/urdf/model.urdf (robot description, URDF)
Before this commit: robot grasslammer, 4 links, 3 joints
Joints:
- added joint base_link_to_oakd: type fixed, parent base_link, child oakd_base, origin xyz=0.26 0 0.004 rpy=0 0 0
